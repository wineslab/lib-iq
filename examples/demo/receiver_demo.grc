options:
  parameters:
    generate_options: qt_gui
    id: receiver_demo
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: center_frequency
  id: variable
  parameters:
    value: '1000000000'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '1000000'
  states: {}
- name: window_size
  id: variable
  parameters:
    value: '256'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /root/demo/iq_samples/iq_sample_captured.bin
    type: complex
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    type: complex
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    size: '1024'
    srate: samp_rate
    type: complex
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    center_freq0: center_frequency
    gain0: '100'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: zeromq_push_sink_0
  id: zeromq_push_sink
  parameters:
    address: tcp://127.0.0.1:55556
    timeout: '100'
    type: complex
    vlen: '2'
  states: {}

connections:
- [blocks_stream_to_vector_0, '0', zeromq_push_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_stream_to_vector_0, '0']
- [uhd_usrp_source_0, '0', qtgui_time_sink_x_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.9.2
